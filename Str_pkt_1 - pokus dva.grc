options:
  parameters:
    author: Barry Duggan
    description: Baseband stream packets
    generate_options: no_gui
    id: str_pkt_1
    output_language: python
    title: |
      Using Header Format CRC and Protocol Parser
  states: {}

blocks:
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\jarab\Desktop\Output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\jarab\Desktop\padded.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"burst"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bytes
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bytes
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_1, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1_0, '0']
- [digital_protocol_formatter_bb_0, '0', header_bits, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [virtual_source_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_1, '0', digital_header_payload_demux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
